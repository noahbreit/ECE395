<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\orange_mc.ewp</path>
  </project>
  <batchBuild />
</workspace>
